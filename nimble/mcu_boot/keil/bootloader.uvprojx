# Keil uVision project bootloader.uvprojx, settings and files
target BootLoader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  AfterMake: cmd.exe /c $J\..\bin\fromelf.exe --bin -o "bin/@L.bin" "#L" && $J\..\bin\fromelf.exe -acd --interleave=source -o "bin/@L.disasm" "#L"
  AfterMake: fromelf -c -o "$L@L.txt" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X2_MODE,NIMBLE_CFG_CONTROLLER=1,NIMBLE_SPARK_SUP
  c include: ..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/arm/: startup_PANSeries.s
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
  group Driver
    ../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_dmac.c pan_fmc.c pan_gpio.c pan_pwm.c pan_uart.c pan_timer.c pan_wdt.c pan_wwdt.c
    ../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_clktrim.c pan_lp.c pan_sys.c retarget.c
  group APP
    ../src/: main.c flash_manager.c signal_slot_manager.c signal.c uart_dfu.c usb_dfu.c prf_ota.c
  group BootConfig
    ../src/: boot_config.c
  group prf
    ../../../modules/hal/panchip/panplat/pan1070/bsp/radio/prf_lib/: prf_lib.lib
    ../../../modules/hal/panchip/panplat/pan1070/bsp/radio/src/: pan_prf_glue.c
