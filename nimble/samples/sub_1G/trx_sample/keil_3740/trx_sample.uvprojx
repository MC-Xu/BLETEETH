# Keil uVision project trx_sample.uvprojx, settings and files
target trx_device2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: trx_sample_dev2 +hex
  AfterMake: post.bat ".\Images\ndk_app.bin"  ".\Images\ndk_app.asm" "#L" ".\Images\ndk_app.bin" "$KARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X2_MODE,NIMBLE_CFG_CONTROLLER=1,NIMBLE_SPARK_SUP,IP_107x,TRX_DEVICE2
  c misc: --preinclude=soc_config.h
  c include: ..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\SEGGER_RTT\RTT;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\sub_1g\include;..\..\..\..\os\freertos\include;..\..\..\..\os\freertos\portable\RVDS\ARM_CM0;..\..\..\..\host\nimble\ext\tinycrypt\include;..\..\..\..\host\nimble\nimble\include;..\..\..\..\host\nimble\nimble\host\include;..\..\..\..\host\nimble\nimble\host\util\include;..\..\..\..\host\nimble\nimble\transport\include;..\..\..\..\host\nimble\porting\nimble\include;..\..\..\..\host\nimble\porting\npl\freertos\include;..\..\..\..\host\nimble\nimble\host\services\gap\include;..\..\..\..\host\nimble\nimble\host\services\gatt\include;..\..\..\..\host\nimble\nimble\host\services\ans\include;..\..\..\..\host\nimble\nimble\host\store\config\include;..\..\..\..\controller\pan107x_spark\include;..\..\..\..\controller\pan107x_spark\include\utils;..\..\..\..\host\kv_store;..\..\..\..\host\nimble\ext\base64\include;.\configuration;..\src;..\..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ./startup/: startup_PANSeries.s
  group Device
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_sys.c pan_lp.c pan_clk.c pan_clktrim.c
  group Peripheral
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_dmac.c pan_fmc.c pan_gpio.c pan_timer.c pan_uart.c pan_wwdt.c pan_pwm.c
  group FreeRTOS/Kernel
    ../../../../os/freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_setup.c
  group FreeRTOS/Port
    ../../../../os/freertos/portable/RVDS/ARM_CM0/: port.c
    ../../../../os/freertos/portable/MemMang/: heap_4.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_lp.c
  group Misc
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/SEGGER_RTT/RTT/: SEGGER_RTT.c
  group host
    ../../../../host/nimble/nimble/host/src/: ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_gatts_lcl.c ble_hs.c ble_hs_adv.c ble_hs_atomic.c ble_hs_cfg.c ble_hs_conn.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_misc.c ble_hs_mqueue.c ble_hs_periodic_sync.c ble_hs_pvcy.c ble_hs_shutdown.c ble_hs_startup.c ble_hs_stop.c ble_ibeacon.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_sm.c ble_sm_alg.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_util.c ble_uuid.c
  group host_misc
    ../../../../host/nimble/ext/tinycrypt/src/: aes_decrypt.c aes_encrypt.c cmac_mode.c ecc.c ecc_dh.c utils.c
    ../../../../host/nimble/nimble/host/util/src/: addr.c
    ../../../../host/nimble/ext/base64/src/: base64.c
  group host_porting
    ../../../../host/nimble/porting/nimble/src/: endian.c mem.c nimble_port.c os_mbuf.c os_mempool.c os_msys_init.c
    ../../../../host/nimble/porting/npl/freertos/src/: npl_os_freertos.c
    ../../../../host/nimble/nimble/transport/src/: transport.c monitor.c
    ././../../../../host/nimble/porting/npl/freertos/src/pan107x/: nimble_glue_spark.c
    ../../../../host/kv_store/: mtb_kvstore.c mtb_init.c
    ../../../../host/nimble/nimble/host/store/config/src/: ble_store_config.c ble_store_config_conf.c
  group host_service
    ../../../../host/nimble/nimble/host/services/gap/src/: ble_svc_gap.c
    ../src/: gatt_svr.c
  group lib
    ./../../../../lib/pan107x_spark/: ble_spark_107x.lib
  group sub_1g
    ../../../../../modules/hal/panchip/panplat/pan1070/sub_1g/src/: sub_1g_base.c sub_1g_port.c
  group User
    ../src/: main.c
    ./configuration/: app_version.c
  group config
    ./configuration/: sdk_config.h
target trx_device1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: trx_sample +hex
  AfterMake: as above
  c flags: as above
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X2_MODE,NIMBLE_CFG_CONTROLLER=1,NIMBLE_SPARK_SUP,IP_107x
  c misc: --preinclude=soc_config.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
