# Keil uVision project gpio_digital_input_interrupt.uvprojx, settings and files
target GPIO (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: gpio_digital_input_interrupt +hex
  AfterMake: post.bat ".\Images\ndk_app.bin"  ".\Images\ndk_app.asm" "#L" ".\Images\ndk_app.bin" "$KARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X2_MODE,IP_107x
  c misc: --preinclude=soc_config.h
  c include: ..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\SEGGER_RTT\RTT;..\..\..\..\os\freertos\include;..\..\..\..\os\freertos\portable\RVDS\ARM_CM0;..\..\..\..\os\freertos\portable\RVDS\ARM_CM0\pan107x;..\..\..\..\host\nimble\ext\tinycrypt\include;..\..\..\..\host\nimble\nimble\include;..\..\..\..\host\nimble\nimble\host\include;..\..\..\..\host\nimble\nimble\host\util\include;..\..\..\..\host\nimble\nimble\transport\include;..\..\..\..\host\nimble\porting\nimble\include;..\..\..\..\host\nimble\porting\npl\freertos\include;..\..\..\..\host\nimble\nimble\host\services\gap\include;..\..\..\..\host\nimble\nimble\host\services\gatt\include;..\..\..\..\host\nimble\nimble\host\store\ram\include;..\..\..\..\controller\pan107x_spark\include;..\..\..\..\controller\pan107x_spark\include\utils;.\configuration;..\src;..\..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ./startup/: startup_PANSeries.s
  group Device
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_sys.c pan_lp.c pan_clktrim.c pan_clk.c pan_power.c
  group Peripheral
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_dmac.c pan_fmc.c pan_gpio.c pan_timer.c pan_uart.c pan_wwdt.c pan_adc.c pan_wdt.c
  group HAL
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_hal_gpio.c
  group FreeRTOS/Kernel
    ../../../../os/freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_setup.c
  group FreeRTOS/Port
    ../../../../os/freertos/portable/RVDS/ARM_CM0/: port.c
    ../../../../os/freertos/portable/MemMang/: heap_4.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_lp.c
  group Misc
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/SEGGER_RTT/RTT/: SEGGER_RTT.c
  group User
    ../src/: main.c
    ./configuration/: app_version.c
  group config
    ./configuration/: sdk_config.h
