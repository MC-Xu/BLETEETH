# Keil uVision project prf_dongle.uvprojx, settings and files
target prf_dongle (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: prf_dongle +hex
  AfterMake: post.bat ".\Images\ndk_app.bin"  ".\Images\ndk_app.asm" "#L" ".\Images\ndk_app.bin" "$KARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X2_MODE CONFIG_PRF_REDUCE_TRX_TRANS_TIME=1
  c misc: --preinclude=sample_config_1M_xn297.h
  c include: ..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\src;..\src\usb;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ../startup/: startup_PANSeries.s
  group drivers
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_clk.c pan_clktrim.c pan_sys.c retarget.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_i2c.c pan_pwm.c pan_spi.c pan_timer.c pan_uart.c pan_wdt.c pan_wwdt.c
  group prf
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/radio/src/: pan_prf_glue.c
  group config
    ../include/: image_map_config.h
  group User
    ../src/: common.h main.c mouse_prf.c mouse_usb.c ring_buffer.c
    ../include/: app_version.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/radio/prf_lib/: prf_lib.lib
  group usb
    ../src/usb/: endpoint.c endpoint0.c musbfsfc.c usb_panchip.c
