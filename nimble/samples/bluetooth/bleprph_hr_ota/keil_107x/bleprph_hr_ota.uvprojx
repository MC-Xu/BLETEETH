# Keil uVision project bleprph_hr_ota.uvprojx, settings and files
target bleprph_hr_spark_ota (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bleprph_hr_ota +hex
  AfterMake: post.bat ".\Images\ndk_app.bin"  ".\Images\ndk_app.asm" "#L" ".\Images\ndk_app.signed" "$KARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=FLASH_X2_MODE,NIMBLE_CFG_CONTROLLER=1,NIMBLE_SPARK_SUP,__ORDER_LITTLE_ENDIAN__=2,__BYTE_ORDER__=2,IP_107x
  c misc: --preinclude=PanSeries.h --preinclude=soc_config.h
  c include: ..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\cmsis\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\peripheral\inc;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\device\Include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\radio\prf_lib\include;..\..\..\..\..\modules\hal\panchip\panplat\pan1070\bsp\SEGGER_RTT\RTT;..\..\..\..\os\freertos\include;..\..\..\..\os\freertos\portable\RVDS\ARM_CM0;..\..\..\..\host\nimble\ext\tinycrypt\include;..\..\..\..\host\nimble\nimble\include;..\..\..\..\host\nimble\nimble\host\include;..\..\..\..\host\nimble\nimble\host\util\include;..\..\..\..\host\nimble\nimble\transport\include;..\..\..\..\host\nimble\porting\nimble\include;..\..\..\..\host\nimble\porting\npl\freertos\include;..\..\..\..\host\nimble\nimble\host\services\gap\include;..\..\..\..\host\nimble\nimble\host\services\gatt\include;..\..\..\..\host\nimble\nimble\host\store\ram\include;..\..\..\..\controller\pan107x_spark\include;..\..\..\..\controller\pan107x_spark\include\utils;.\configuration;..\src;..\..\..\..\host\smp_bt;..\..\..\..\host\smp_bt\tinycbor\include;..\..\..\..\host\smp_bt\mcumgr\smp\include;..\..\..\..\host\smp_bt\mcumgr\mgmt\include;..\..\..\..\host\smp_bt\mcumgr\cborattr\include;..\..\..\..\host\smp_bt\mcumgr\img_mgmt\include;..\..\..\..\host\smp_bt\mcumgr\util\include;..\..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\project.sct
  link misc: --entry Reset_Handler
  group CMSIS
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: system_PANSeries.c
    ./startup/: startup_PANSeries.s
  group Device
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: pan_sys.c pan_lp.c pan_clktrim.c pan_clk.c pan_power.c
  group Peripheral
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_adc.c pan_dmac.c pan_fmc.c pan_gpio.c pan_timer.c pan_uart.c pan_wwdt.c
  group HAL
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/peripheral/src/: pan_hal_adc.c
  group FreeRTOS/Kernel
    ../../../../os/freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_setup.c
  group FreeRTOS/Port
    ../../../../os/freertos/portable/RVDS/ARM_CM0/: port.c
    ../../../../os/freertos/portable/MemMang/: heap_4.c
    ../../../../os/freertos/portable/RVDS/ARM_CM0/pan107x/: os_lp.c
  group Misc
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/device/Source/: retarget.c
    ../../../../../modules/hal/panchip/panplat/pan1070/bsp/SEGGER_RTT/RTT/: SEGGER_RTT.c
  group host
    ../../../../host/nimble/nimble/host/src/: ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_gatts_lcl.c ble_hs.c ble_hs_adv.c ble_hs_atomic.c ble_hs_cfg.c ble_hs_conn.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_misc.c ble_hs_mqueue.c ble_hs_periodic_sync.c ble_hs_pvcy.c ble_hs_shutdown.c ble_hs_startup.c ble_hs_stop.c ble_ibeacon.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_sm.c ble_sm_alg.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_util.c ble_uuid.c
    ../../../../host/nimble/nimble/host/store/ram/src/: ble_store_ram.c
  group host_misc
    ../../../../host/nimble/ext/tinycrypt/src/: aes_decrypt.c aes_encrypt.c cmac_mode.c ecc.c ecc_dh.c utils.c
    ../../../../host/nimble/nimble/host/util/src/: addr.c
  group host_porting
    ../../../../host/nimble/porting/nimble/src/: endian.c mem.c nimble_port.c os_mbuf.c os_mempool.c os_msys_init.c
    ../../../../host/nimble/porting/npl/freertos/src/: npl_os_freertos.c
    ../../../../host/nimble/nimble/transport/src/: transport.c monitor.c
    ./../../../../host/nimble/porting/npl/freertos/src/pan107x/: nimble_glue_spark.c
  group host_service
    ../../../../host/nimble/nimble/host/services/gap/src/: ble_svc_gap.c
    ../src/: gatt_svr.c
  group smp_ota
    ../../../../host/smp_bt/app_smp/: smp_ble.c
    ../../../../host/smp_bt/os_smp/src/: smp.c
    ../../../../host/smp_bt/mcumgr/smp/src/: mcumgr_smp.c
    ../../../../host/smp_bt/mcumgr/mgmt/src/: mgmt.c
    ../../../../host/smp_bt/tinycbor/src/: cbor_mbuf_reader.c cbor_mbuf_writer.c cborencoder.c cborparser.c cbor_buf_reader.c
    ../../../../host/smp_bt/mcumgr/cborattr/src/: cborattr.c
    ../../../../host/smp_bt/mcumgr/img_mgmt/src/: img_mgmt.c img_mgmt_state.c img_mgmt_util.c
    ../../../../host/smp_bt/mcumgr/img_mgmt/port/mynewt/src/: mynewt_img_mgmt.c
  group lib
    ../../../../lib/pan107x_spark/: ble_spark_107x.lib
  group User
    ../src/: main.c
    ./configuration/: app_version.c
  group config
    ./configuration/: sdk_config.h
